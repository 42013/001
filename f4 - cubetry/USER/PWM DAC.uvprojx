# Keil uVision project PWM DAC.uvprojx, settings and files
target PWM DAC (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F407ZG STMicroelectronics
  pack: Keil.STM32F4xx_DFP.1.0.8
  cpu: IROM(0x08000000,0x100000) IRAM(0x20000000,0x20000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(168000000) ELITTLE
  output: PWM_DAC +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F40_41xxx,USE_STDPERIPH_DRIVER
  c include: ..\CORE;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\HARDWARE\LED;..\HARDWARE\LCD;..\HARDWARE\KEY;..\HARDWARE\ADC;..\HARDWARE\PWM_DAC;..\HARDWARE\Relays;..\HARDWARE\motion;..\HARDWARE\motion2;..\HARDWARE\motion3;..\HARDWARE\motion4;..\HARDWARE\motion5;..\HARDWARE\motion6;..\HARDWARE\inmotion;..\FWLIB\inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group USER
    ./: main.c stm32f4xx_it.c system_stm32f4xx.c
  group HARDWARE
    ../HARDWARE/PWM_DAC/: pwmdac.c
    ../HARDWARE/Relays/: Relays.c
    ../HARDWARE/motion/: motion.c
    ../HARDWARE/motion2/: motion2.c
    ../HARDWARE/motion3/: motion3.c
    ../HARDWARE/motion4/: motion4.c
    ../HARDWARE/motion5/: motion5.c
    ../HARDWARE/motion6/: motion6.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: startup_stm32f40_41xxx.s
  group FWLIB
    ../FWLIB/src/: misc.c stm32f4xx_dbgmcu.c stm32f4xx_gpio.c stm32f4xx_fsmc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c stm32f4xx_adc.c stm32f4xx_rcc.c
  group README
    ../: readme.txt
